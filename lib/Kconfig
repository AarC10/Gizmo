## lib/gizmo/Kconfig
```kconfig
# Copyright (c) 2024 Aaron Chan

config GIZMO
    bool "Gizmo Libraries"
    help
      Gizmo Libraries
```
